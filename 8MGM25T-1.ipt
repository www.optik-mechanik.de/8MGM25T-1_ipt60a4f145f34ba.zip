# Autodesk Inventor part: 8GM25T-2
## iProperties
Created: 2008-09
Part Number: 8GM25T-2
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
